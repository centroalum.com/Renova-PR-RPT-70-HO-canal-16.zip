Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-06-07T12:00:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 07 12:00:37 2016 * Host: BICHO-B03 * Database: C:\Users\JORDIG~1\AppData\Local\Temp\{1D8852DA-148C-41C6-8750-CFF2D8935152}\ifc * Database version: 5507 * Database creation date: Tue Jun 07 12:00:37 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 07 12:00:37 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 07 12:00:37 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Restricciones - Altura base: Punto base del proyecto; Alzado: 0 m
Cotas - Altura de cálculo: 0 m
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes; Nombre de tipo: Nivel 1
Otros - Categoría: Niveles; Familia: Nivel: Nivel 1; Familia y tipo: Nivel: Nivel 1; ID de tipo: Nivel: Nivel 1; Tipo: Nivel: Nivel 1; Nombre de familia: Nivel
Gráficos - Color: 0; Grosor de línea: 1; Patrón de línea: Trazo punto; Símbolo: Extremo de nivel: Extremo de nivel; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcWindow: Ventana 1 hoja 800x1480, 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16:Ventana 1 hoja 800x1480:162749
In: Nivel 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Vidrio, Aluminio
Type - Construcción - Altura de antepecho por defecto: 0.8 m; CerramientoExterior: yes; Cierre de muro: Por anfitrión; Configuración de poliamidas: 418200 // 956059 // 506400; ControlHumos: no; Máximo hueco acristalar (mm): 0.028 m; Motorizada: no; PERFILES SECCIÓN - Hoja: 79.2156; PERFILES SECCIÓN - Junquillo: GO579000; PERFILES SECCIÓN - Marco: 79.1136; RepisaExterior: no; RepisaInterior: no; Rotura de puente térmico (mm): 28 / 37; SalidaEmergencia: no; Sección de hoja (mm): 38 Hoja oculta; Sección de marco (mm): 70
Type - Cotas - Altura: 1.48 m; AlturaManija: 1.1 m; Anchura: 0.8 m; DesfaseExterior: 0 m; DM_AlturaCristal: 1.41367 m; GrosorMarco: 0.07 m; LíneaProyección: 0.768 m
Type - Datos - Área: 1.184 m2; EstanqueidadAgua: CLASE 9A; MasaSuperficialKgm2: 0; ResistenciaAlViento: CLASE C5; TransmitanciaTérmica: 1.5
Type - Datos de identidad - Autor: Bimetica Parametric Design Services, S.L.; Bimetica: http://www.bimetica.com; CódigoMasterformat: 08 51 13 - Aluminium Windows; CódigoUniclass2.0: 25-30 - Door and window systems; CódigoUNSPSC: 30171600 - Windows; Descripción: Ventana 1 hoja 800 x 1480; Fabricante: CENTROALUM SA; FechaEmisiónElementoBIM: 09/05/2016; FechaVencimientoElementoBIM: 01/01/2017; Marca de tipo: 23; Modelo: Renova PR RPT 70 HO canal 16; Nombre de tipo: Ventana 1 hoja 800x1480; Número OmniClass: 23.30.20.00; ReferenciaContacto: Departamento Técnico de Centroalum; TeléfonoContacto: +34 93 712 29 11; Título OmniClass: Windows; URL: http://centroalum.com/; URL Poliamida: http://www.technoform.es/; URL Poliamida - Catálogo: http://www.technoform.com/fileadmin/Technoform_Bautec/standardprofiles.html; URLProducto: http://centroalum.com/es/Windows/46/284/; VersiónElementoBIM: 1.0
Type - General - CosteMantenimiento: 0; MateriaPrima: 0
Type - Materiales y acabados - Acabado: Lacado colores RAL / Lacado colores especiales / Lacado imitación madera / Lacado madera polvo sobre polvo / Anodizado / Posibilidad bicolor; Acristalamiento: Vidrio; Marco: Aluminio; Poliamida: Poliamida, Technoform Bautec, PA66 GF 25
Type - Otros - Categoría: Ventanas; Nombre de familia: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16
Type - Propiedades analíticas - Construcción analítica: <Ninguno>
Type - Propiedades de Green Building - AcidificaciónAtmosférica: 0; AcidificaciónAtmosféricaPorUnidad: 0; AguaConsumidaPorUnidad: 0; CambioClimático: 0; CambioClimáticoPorUnidad: 0; ConsumoAgua: 0; CosnsumoEnergíaPrimariaTotal: 0; CosteEnergéticoKwh: 0; CosteEnergéticoMj: 0; DestrucciónCapaOzonoEstratosférica: 0; DestrucciónCapaOzonoEstratosféricaPorUnidad: 0; EmisiónCO2: 0; EnergíaNoRenovableConsumida: 0; EnergíaNoRenovableConsumidaPorUnidad: 0; EnergíaPrimariaTotalConsumidaPorUnidad: 0; EnergíaRenovableConsumida: 0; EnergíaRenovableConsumidaPorUnidad: 0; Eutrofización: 0; EutrofizaciónPorUnidad: 0; FaltaDeRecurso: 0; FaltaDeRecursosPorUnidad: 0; FormaciónFotoquímicaOzono: 0; FormaciónFotoquímicaOzonoPorUnidad: 0; ResiduoInerte: 0; ResiduoInertePorUnidad: 0; ResiduoRadioactivo: 0; ResiduoRadioactivoPorUnidad: 0; ResiduosNoPeligrosos: 0; ResiduosNoPeligrososPorUnidad: 0; ResiduosPeligrosos: 0; ResiduosPeligrososPorUnidad: 0
Type - Resultados de análisis - FactorSolarModificado: 0; FactorSombra: 0; FracciónÁreaAcristalamiento: 0; PermeabilidadAlAire: CLASE 4; Transmitancia térmica Marco/Hoja (Uh/m): 2,4 (W/m K); Transmitancia térmica Nudo central (Uh/m): 2,3 (W/m K)
OverallHeight: 1.48 m; OverallWidth: 0.8 m
Pset_WindowCommon - Reference: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16:Ventana 1 hoja 800x1480; IsExternal: yes
Pset_ManufacturerTypeInformation - Manufacturer: CENTROALUM SA
Cotas - Área: 2.42262 m2; DesfaseInterior: 0 m; Volumen: 0.0294433 m3
Datos de identidad - Marca: 7
Otros - Altura de extremo inicial: 2.28 m; Familia: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16: Ventana 1 hoja 800x1480; Familia y tipo: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16: Ventana 1 hoja 800x1480; ID de anfitrión: Muro básico: Por defecto - 20 cm; ID de tipo: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16: Ventana 1 hoja 800x1480; Tipo: 2014_Ventana_Centroalum_Renova-PR-1H-RPT-70-HO-canal-16: Ventana 1 hoja 800x1480
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Altura de antepecho: 0.8 m; Nivel: Nivel: Nivel 1
Visibilidad - Detalle Perfileria: no; Manija: yes; Proyección Apertura: no
